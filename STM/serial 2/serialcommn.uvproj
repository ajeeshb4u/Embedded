# Keil uVision project serialcommn.uvproj, settings and files
target stm32f103 flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: serialcommn
  c flags: Optim=1
  c define: STM32F10X_MD __USART2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start up
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group userpgm
    ./: main.c Serial.c
