# Keil uVision project SPI_IT.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SPI_IT
  c flags: Optim=1
  c include: .\Drivers\BSP;.\src;.\Inc;.\Drivers\STM32F1xx_HAL_drivers\Inc;.\Drivers\CMSIS\Inc;.\src;.\Drivers\CMSIS\Src;.\Drivers\CMSIS\Inc;.\Drivers\STM32F1xx_HAL_drivers\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group Main Group
    ./src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group BSP
    ./Drivers/BSP/: stm32f1xx_nucleo.c
  group Hal_Drivers
    ./Drivers/STM32F1xx_HAL_drivers/src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group CMSIS
    ./Drivers/CMSIS/Inc/: system_stm32f1xx.c
