# Keil uVision project spi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: spi
  c flags: Optim=1
  c define: STM32F10X_MD __USART1
  asm define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s main.c system_stm32f10x.c
    ./include/: serial.c stm32f10x_rcc.h
